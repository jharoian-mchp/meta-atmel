LDFLAGS += "-Wl,--no-keep-memory"

